# Keil uVision project HC32F103.uvprojx, settings and files
target TEST (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F103CB Holychip
  pack: Holychip.M3.1.0.2
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HC32F103.axf +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\LIB\HC32F10x_StdPeriph_Driver\inc;.\LIB\CMSIS\CM3\CoreSupport;.\LIB\CMSIS\CM3\DeviceSupport\HC\HC32F10x;..\HC32F103;..\..\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: hc32f10x_it.c Main.c uart.c port.c snprintf.c
  group HC32_LIB
    ./LIB/HC32F10x_StdPeriph_Driver/src/: hc32f10x_adc.c hc32f10x_bkp.c hc32f10x_can.c hc32f10x_crc.c hc32f10x_dbgmcu.c hc32f10x_dma.c hc32f10x_exti.c hc32f10x_flash.c hc32f10x_gpio.c hc32f10x_i2c.c hc32f10x_iwdg.c hc32f10x_pwr.c hc32f10x_rcc.c hc32f10x_rtc.c hc32f10x_spi.c hc32f10x_tim.c hc32f10x_usart.c hc32f10x_wwdg.c misc.c
  group MDK_STARTUP
    ./LIB/CMSIS/CM3/DeviceSupport/HC/HC32F10x/startup/arm/: startup_hc32f10x_md.s
  group CMSIS
    ./LIB/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./LIB/CMSIS/CM3/DeviceSupport/HC/HC32F10x/: system_hc32f10x.c
  group Src
    ../../src/: Coroutine.c Coroutine.h Define.h NodeLink.c NodeLink.h Universal.h RBTree.c
